# Keil uVision project infusion.uvprojx, settings and files
target infusion (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151R8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: infusion +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ../Inc;      ../Drivers/STM32L1xx_HAL_Driver/Inc;      ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;      ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;      ../Drivers/CMSIS/Include;      ..\BSP;      ..\USER;      ..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group BSP
    ../BSP/: bsp_ad7799.c bsp.c bsp_12864.c bsp_ble.c
  group USER
    ../USER/: ad7799.c display_ui.c sys_data.c ring_buffer.c eeprom.c sys_info.c save_data.c CRC_Check.c misc.c lcd_code.c protocol.c sys_alarm.c
  group APP
    ../APP/: TaskManage.c KeyScanTask.c WeighTask.c BLETask.c UITask.c SysMonitorTask.c UartTask.c
  group Application/User
    ../Src/: main.c gpio.c spi.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c dma.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_spi.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
